TOOLCHAIN_HOST_TASK += "nativesdk-packagegroup-gallus-toolchain-host"
TOOLCHAIN_TARGET_TASK += "packagegroup-gallus-toolchain-target"
