PR="r1"
LOGROTATE_SYSTEMD_TIMER_BASIS ?= "hourly"
LOGROTATE_SYSTEMD_TIMER_ACCURACY ?= "5m"
