FILES_${PN} += "${bindir}/*"
FILES_${PN}-dbg += "${bindir}/.debug/"
