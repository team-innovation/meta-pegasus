# Look for file in this layer first
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
