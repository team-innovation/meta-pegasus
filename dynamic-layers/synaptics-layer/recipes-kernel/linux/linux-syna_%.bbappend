FILESEXTRAPATHS:prepend := "${THISDIR}/../files:"

SRC_URI += "file://cellular.cfg \
"
