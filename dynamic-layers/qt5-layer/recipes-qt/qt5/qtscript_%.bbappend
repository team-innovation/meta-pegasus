FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCREV = "ebf8d292cd369552c34be8f1cf1b1fd3d2dbad23"

