SRC_URI = " \
     ${QT_GIT}/${QT_MODULE}.git;name=${QT_MODULE};${QT_MODULE_BRANCH_PARAM};protocol=${QT_GIT_PROTOCOL} \
"

SRCREV = "c433697a686e7a24dc4bfd58f2a46c05ae7b7716"

