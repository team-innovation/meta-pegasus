DEPENDS += " python3-setuptools"
