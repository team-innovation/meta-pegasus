# Copyright (C) 2015 Freescale Semiconductor

require imx-gpu-viv-kernel.inc
          
SRC_URI[md5sum] = "6ee0930001525323a1c69dd5a221ce91"
SRC_URI[sha256sum] = "d3ba7bd919078c95281c05500ab5f614253e7690f7eed9bf0a363313b5aeee85"

S = "${WORKDIR}/${PN}-${PV}"
