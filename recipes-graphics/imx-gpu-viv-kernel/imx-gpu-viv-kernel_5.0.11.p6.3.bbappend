# Copyright (C) 2015 Freescale Semiconductor
FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"
SRC_URI += "file://kernel-version.patch"
