require bsp-rt288x-hg.inc

PR = "r2"
