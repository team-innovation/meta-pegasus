PACKAGES += " gst-plugins-good-pulse"

RDEPENDS_gst-plugins-good-pulse += " tcp-wrappers"
