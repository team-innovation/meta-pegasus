PACKAGECONFIG_append = "opus"

DEPENDS += " libopus"

PR = "r1"

