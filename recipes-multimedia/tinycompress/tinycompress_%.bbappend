SRC_URI = "git://github.com/alsa-project/tinycompress.git;protocol=https;branch=master \
           file://0001-tinycompress-Add-id3-decoding.patch \
           file://0002-cplay-Support-wave-file.patch \
           file://0003-cplay-Add-pause-feature.patch \
           file://0004-tinycompress-pass-NULL-buffer-with-0-size-to-driver.patch \
           file://0005-cplay-Support-aac-streams.patch \
	"

