FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PR = "r3"

SRC_URI += "file://variableresolution.patch"
