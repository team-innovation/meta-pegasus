FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PR = "2"

SRC_URI += "file://variableresolution.patch"
