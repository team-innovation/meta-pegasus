RPROVIDES_${PN} += "libqt5declarative5"
