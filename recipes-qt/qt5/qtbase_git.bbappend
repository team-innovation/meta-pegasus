
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

QT_BUILD_PARTS += "examples"
QT_BUILD_PARTS += "tests"

