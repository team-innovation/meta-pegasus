RPROVIDES_${PN} += "libqt5xmlpatterns5"
