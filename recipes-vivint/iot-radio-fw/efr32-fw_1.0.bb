DESCRIPTION = "Bluetooth rail test firmware"

require iot-fw.inc

PR = "r1"

FW_NAME = "vivint_efr32.hex"

