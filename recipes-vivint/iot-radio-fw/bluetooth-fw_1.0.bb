DESCRIPTION = "Bluetooth rail test firmware"

require iot-fw.inc

PR = "r2"

FW_HEX_NAME = "vivint_blue.hex"
FW_NAME = "vivint_blue.fw"
