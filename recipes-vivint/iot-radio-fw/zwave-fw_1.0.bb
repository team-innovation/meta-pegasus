DESCRIPTION = "Zwave rail test firmware"

require iot-fw.inc

PR = "r1"

FW_NAME = "vivint_zwave.hex"

