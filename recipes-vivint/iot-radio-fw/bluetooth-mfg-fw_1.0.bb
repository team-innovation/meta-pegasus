DESCRIPTION = "Bluetooth rail test firmware"

require iot-fw.inc

PR = "r1"

FW_NAME = "railtest_blue.hex"
