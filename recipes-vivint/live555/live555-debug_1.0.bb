# NOTE: DO NOT BUILD IN BUILD.  THIS IS ONLY FOR TESTING.
require live555-shared-debug.inc

PR = "${INC_PR}.1"



