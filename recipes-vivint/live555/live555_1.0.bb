LIC_FILES_CHKSUM = "file://COPYING;md5=68ad62c64cc6c620126241fd429e68fe"

require live555-shared.inc

PR = "${INC_PR}.1"



