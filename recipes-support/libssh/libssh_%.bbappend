SRC_URI = "git://git.libssh.org/projects/libssh.git;branch=v0-6;protocol=https"
SRCREV = "6e0dee7845cea22f59bd353ef42b31cb67170030"
