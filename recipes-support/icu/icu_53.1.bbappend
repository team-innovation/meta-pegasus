FILESEXTRAPATHS_prepend := "${THISDIR}/icu:"

SRC_URI += "file://LICENSE"

LIC_FILES_CHKSUM = ""
LIC_FILES_CHKSUM = "file://../../LICENSE;md5=ac059d0a5f0ae0970f49adb008e8dbb2"
