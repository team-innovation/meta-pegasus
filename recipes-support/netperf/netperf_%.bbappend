EXTRA_OECONF="--enable-demo"

PR="r1"
