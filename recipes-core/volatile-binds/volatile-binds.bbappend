VOLATILE_BINDS = "\
    /media/extra/lib /var/lib\n\
    /media/extra/cache /var/cache\n\
    /media/extra/log /var/log\n\
    /media/extra/spool /var/spool\n\
    /media/extra/srv /srv\n\
    /media/extra/etc /etc\n\
    /media/extra/opt /opt\n\
    /media/extra/root /root\n\
"

