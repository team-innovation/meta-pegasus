FILESEXTRAPATHS_prepend := "${THISDIR}/sysvinit:"

PR = "15"
