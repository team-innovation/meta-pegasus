FILES:${PN} += "/media/extra"
