SUMMARY = "Basic inter-process locks"
HOMEPAGE = "https://github.com/zopefoundation/zc.lockfile"
SECTION = "devel/python"

LICENSE = "ZPL-2.1"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5="

PYPI_PACKAGE = "zc.lockfile"

SRC_URI[sha256sum] = ""

inherit setuptools3 pypi