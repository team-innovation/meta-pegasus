# Allows us to create a native package for staging in OE
BBCLASSEXTEND = "native nativesdk"
