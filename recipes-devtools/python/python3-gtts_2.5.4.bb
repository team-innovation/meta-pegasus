SUMMARY = "gTTS (Google Text-to-Speech), a Python library and CLI tool to interface with Google Translate text-to-speech API"
HOMEPAGE = "https://github.com/pndurette/gTTS"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3f9e2857e297482569ee81ba5205ce4b"

SRC_URI[sha256sum] = "f5737b585f6442f677dbe8773424fd50697c75bdf3e36443585e30a8d48c1884"

inherit python_setuptools_build_meta pypi