SUMMARY = "C-style structs for Python"
HOMEPAGE = "https://github.com/andreax79/python-cstruct"
SECTION = "devel/python"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5="

SRC_URI[sha256sum] = "1e7af7b52c8dd3a6ad66df7e481150e4e273ec508950b4a0051e116375b7f28a"

inherit setuptools3 pypi