SUMMARY = "Generate simple tables in terminals from a nested list of strings."
HOMEPAGE = "https://github.com/matthewdeanmartin/terminaltables3"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5="

SRC_URI[sha256sum] = ""

inherit python_setuptools_build_meta pypi