SUMMARY = "Python module for Near Field Communication."
HOMEPAGE = "https://github.com/nfcpy/nfcpy"
SECTION = "devel/python"

LICENSE = "EUPL-1.1"
LIC_FILES_CHKSUM = "file://LICENSE;md5="

SRC_URI[sha256sum] = ""

inherit setuptools3 pypi