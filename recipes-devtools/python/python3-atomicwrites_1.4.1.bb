SUMMARY = "Atomic file writes."
HOMEPAGE = "https://github.com/untitaker/python-atomicwrites"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5="

PYPI_PACKAGE = "async_generator"
SRC_URI[sha256sum] = ""

inherit setuptools3 pypi