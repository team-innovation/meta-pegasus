SUMMARY = "Access dict values as attributes (works recursively)."
HOMEPAGE = "https://github.com/makinacorpus/easydict"
SECTION = "devel/python"

LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI[sha256sum] = "b1135dedbc41c8010e2bc1f77ec9744c7faa42bce1a1c87416791449d6c87780"

inherit setuptools3 pypi