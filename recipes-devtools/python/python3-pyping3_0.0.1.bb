SUMMARY = "A pure python ICMP ping implementation using raw sockets"
HOMEPAGE = "https://github.com/toxinu/pyping"
SECTION = "devel/python"

LICENSE = "GPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=75181f099805ec9c345d64aecd0eae2c"

SRC_URI[sha256sum] = "5b5f7cb39add96cfdd71e04086305cdc4ea3cc5e156cdff09fc05d645712d325"

inherit setuptools3 pypi
