SUMMARY = "Secure HTTP request signing using the HTTP Signature draft specification"
HOMEPAGE = "https://github.com/ahknight/httpsig"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5="

SRC_URI[sha256sum] = "71d6d50246129c4f7cfec20f5e57e351d2b8492d631cc2aa967914acf91f6ce6"

inherit setuptools3 pypi