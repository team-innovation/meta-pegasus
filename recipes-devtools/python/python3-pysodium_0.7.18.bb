SUMMARY = "python libsodium wrapper"
HOMEPAGE = "https://github.com/stef/pysodium"
SECTION = "devel/python"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5="

SRC_URI[sha256sum] = ""

inherit setuptools3 pypi