SUMMARY = "PyDev.Debugger (used in PyDev, PyCharm and VSCode Python)"
HOMEPAGE = "https://github.com/fabioz/PyDev.Debugger"
SECTION = "devel/python"

LICENSE = "EPL-1.0"
LIC_FILES_CHKSUM = "file://LICENSE-EPL;md5="

SRC_URI[sha256sum] = ""

inherit setuptools3 pypi