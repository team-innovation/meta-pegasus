SUMMARY = "Asyncio ping implementation"
HOMEPAGE = "https://github.com/stellarbit/aioping"
SECTION = "devel/python"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://LICENSE;md5="

SRC_URI[sha256sum] = ""

inherit setuptools3 pypi