BBCLASSEXTEND = "native nativesdk"

RDEPENDS_${PN}_class-native = "\
    ${PYTHON_PN}-threading \
    ${PYTHON_PN}-io \
    ${PYTHON_PN}-shell \
"

