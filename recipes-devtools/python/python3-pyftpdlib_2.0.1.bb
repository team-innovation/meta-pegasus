SUMMARY = "Very fast asynchronous FTP server library"
HOMEPAGE = "https://github.com/giampaolo/pyftpdlib"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5="

SRC_URI[sha256sum] = "ef0d172a82bfae10e2dec222e87533514609d41bf4b0fd0f07e29d4380fb96bf"

inherit python_setuptools_build_meta pypi