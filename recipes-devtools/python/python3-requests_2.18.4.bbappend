FILESEXTRAPATHS_prepend := "${THISDIR}/python3-requests:"

SRC_URI_append = " file://version_compatibility_warning.patch"

