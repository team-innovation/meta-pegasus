SUMMARY = "cChardet is high speed universal character encoding detector."
HOMEPAGE = "https://github.com/PyYoshi/cChardet"
SECTION = "devel/python"

LICENSE = "MPL-1.1"
LIC_FILES_CHKSUM = "file://COPYING;md5="

SRC_URI[sha256sum] = ""

inherit setuptools3 pypi