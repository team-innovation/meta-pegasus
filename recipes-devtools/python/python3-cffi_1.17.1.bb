SUMMARY = "Foreign Function Interface for Python calling C code."
HOMEPAGE = "https://github.com/python-cffi/cffi"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5="

SRC_URI[sha256sum] = ""

inherit setuptools3 pypi