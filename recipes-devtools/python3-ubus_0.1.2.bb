SUMMARY = "Python bindings for libubus."

LICENSE = "LGPL-2.0-or-later"
# The actual license files live in the upstream libgpiod from which the pypi
# package is spun out.
LIC_FILES_CHKSUM = "LICENSE;md5=4fbd65380cdd255951079008b364516c"

inherit setuptools3 pypi