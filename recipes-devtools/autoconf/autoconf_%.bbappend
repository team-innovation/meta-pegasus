LICENSE = " GPLv2 & GPL-3.0-with-autoconf-exception"
LIC_FILES_CHKSUM += " file://COPYING.EXCEPTION;md5=fdef168ebff3bc2f13664c365a5fb515"
