LICENSE_e2fsprogs-dumpe2fs = "GPLv2"
PACKAGES =+ "e2fsprogs-dumpe2fs"
FILES_e2fsprogs-dumpe2fs = "${base_sbindir}/dumpe2fs"



LICENSE_e2fsprogs-resize2fs = "GPLv2"
PACKAGES =+ "e2fsprogs-resize2fs"
FILES_e2fsprogs-resize2fs = "${base_sbindir}/resize2fs*"
